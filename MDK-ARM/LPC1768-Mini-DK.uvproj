# Keil uVision project LPC1768-Mini-DK.uvproj, settings and files
target LPC1768-Mini-DK (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1768-Mini-DK +hex
  c flags: Optim=1 OneElfS=1
  c define: CFG_SDCARD
  c misc: --c99
  c include: ..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx;..\USER;..\USER\USB;..\..\USBHostLite_LPC17xx.001(FATFS)\USER\UsbHost\Include;..\..\USBHostLite_LPC17xx.001(FATFS)\USER\UsbHost\Host
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ../USER/: main.c lpc17xx_libcfg.h mmc.c ssp.c
  group USB
    ../USER/USB/: mscuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group LPC1700CMSIS_Firmware_Library
    ../Libraries/LPC1700CMSIS_Firmware_Library/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_clkpwr.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c
  group CMSIS
    ../Libraries/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Startup
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group Doc
    ../: readme.txt
  group Host
    ./: usbhost_lpc17xx.c
